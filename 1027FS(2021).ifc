Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-06T15:30:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 06 15:30:04 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{6828CDD2-F988-4104-9503-5835DDB3F4F8}\ifc * Database version: 5507 * Database creation date: Fri Aug 06 15:30:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 06 15:30:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 06 15:30:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1027FS Utility room faucet with dishwasher valve, 1027FS(2021):1027FS Utility room faucet with dishwasher valve:358955
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 253.943 mm; FaucetNominalHeight: 183.5 mm; FaucetNominalWidth: 53.8651 mm; HandShowerNominalDepth: 78.2203 mm; HandShowerNominalHeight: 359.612 mm; HandShowerNominalWidth: 43.0709 mm; InletConnectionSize: 10 mm; Projection: 214 mm
Type - General - Author: BIMstone; BIMObjectName: 1027FS(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for kitchen; NBSReference: 45-35-70/315; ProductInformation: Utility room faucets; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 22/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150098642; EN Standard: EN 817; LVI Number: 6219178; Noise Class: I (ISO 3822)
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1027FS; Catalog Drawing URL: http://static.oras.com/catdrw/1027FS; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1027FS; FDV Document URL: http://www.oras.com/datasheet/1027FS/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1027FS; Group: Utility room faucets; Manufacturer: Oras; Model: 1027FS Utility room faucet with dishwasher valve; Name_en: 1027FS Utility room faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 3.12 kg; Product Code: 1027FS; Product Datasheet: http://www.oras.com/datasheet/1027FS/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1027FS; Product URL: http://static.oras.com/1027FS; Technical DataSheet URL: http://www.oras.com/datasheet/1027FS/en; Type Name: 1027FS Utility room faucet with dishwasher valve
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: CASCADE®; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00494405 m3/s; Installation and Maintenance: http://static.oras.com/manual/1027FS; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Pressure Loss With Flow 02ls: 160000 Pa; Spare Parts: http://static.oras.com/sp/1027FS; Spout Swivel Range: 120° (80° / 40°); Spout Type: Swivel spout;;; Temperature: Temperature limiter; Temperature Adjustments: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1027FS(2021); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1027FS; Name: 1027FS Utility room faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:55x255x185 mm / Hand shower: 45x80x360 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.118236 m2; Volume: 0.00372556 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1027FS(2021): 1027FS Utility room faucet with dishwasher valve; Family and Type: 1027FS(2021): 1027FS Utility room faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1027FS(2021): 1027FS Utility room faucet with dishwasher valve; Type Id: 1027FS(2021): 1027FS Utility room faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
